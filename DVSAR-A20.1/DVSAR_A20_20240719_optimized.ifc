Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DVSAR_A20_20240719.IFC
Time: 2024-07-19T10:43:56
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Part1^Assem1
In: Default Storey
PredefinedType: ELEMENT
